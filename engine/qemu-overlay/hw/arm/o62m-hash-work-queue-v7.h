#ifndef O62M_HASH_WORK_QUEUE_V7_H
#define O62M_HASH_WORK_QUEUE_V7_H
#include "o62m-te-capabilities-v3.h"
#include <string.h>
/* Explicit fresh host0 SCA/HASH queues. A supported INIT frame is accepted:
 * A supported INIT command may be captured in real bounded CQ storage, but
 * no work or completion is performed here. CSQ/KEY reads remain strict. Thus occupancy/error/
 * finish counts derive from genuinely empty backing, never synthetic work.
 * Virtual policy: HOST_RUN on an empty engine selects INACTIVE; no implicit
 * completion/watermark edge/IRQ/reset/self-clear is generated by config. */
typedef struct O62MHashWorkHostV7 {
 uint32_t control,mask[3],suspend,pending[3];
 uint32_t cq[31],csq[15];
 unsigned cq_words,csq_words,finish_words;
} O62MHashWorkHostV7;
typedef struct O62MHashWorkQueueV7 {
 const O62MTeCapabilitiesV3 *caps;
 O62MHashWorkHostV7 host[2]; /* 0=SCA,1=HASH */
 bool initialized;
} O62MHashWorkQueueV7;
static inline bool o62m_hash_work_queue_init_v7(O62MHashWorkQueueV7 *m,const O62MTeCapabilitiesV3 *caps,
 const uint32_t *words,unsigned count)
{
 uint64_t cq;
 if(!m||!caps||!words||count!=10||
    o62m_te_caps_access_v3(caps,caps->owner,UINT64_C(0x5033000c),4,false,&cq)||
    !(cq&31)||!((cq>>5)&31)||(words[0]&255)||(words[1]&255))return false;
 O62MHashWorkQueueV7 next={0};next.caps=caps;next.initialized=true;
 next.host[0].control=words[0];next.host[1].control=words[1];
 for(unsigned n=0;n<2;n++) {
  for(unsigned i=0;i<3;i++)next.host[n].mask[i]=words[2+4*n+i];
  next.host[n].suspend=words[5+4*n];
 }
 *m=next;return true;
}
static inline unsigned o62m_hash_frame_words_v7(const O62MHashWorkHostV7 *h,uint32_t command)
{
 if(command==UINT32_C(0x80000101))return 3;
 if(command==UINT32_C(0x80000111)||command==UINT32_C(0x80000115)||command==UINT32_C(0x80000119))return 5;
 if(command==UINT32_C(0x40000019))return 4;
 if(command==UINT32_C(0x40000003))return 3;
 if(command==UINT32_C(0x40000039))return 1;
 if(command==UINT32_C(0x2000003f))return h&&(h->finish_words==3||h->finish_words==7)?h->finish_words:0;
 if(command==UINT32_C(0xff000001))return 1;
 return 0;
}
static inline bool o62m_hash_work_queue_access_v7(O62MHashWorkQueueV7 *m,
 uint64_t address,unsigned size,bool write,uint64_t *value)
{
 if(!m||!value||!m->initialized||!m->caps||size!=4||(address&3)||
    (write&&*value>UINT32_MAX)||
    o62m_te_caps_overlap_v3(m,sizeof(*m),value,sizeof(*value)))return false;
 uint64_t cq;
 if(o62m_te_caps_access_v3(m->caps,m->caps->owner,UINT64_C(0x5033000c),4,false,&cq))return false;
 unsigned n;uint64_t base;
 if(address>=UINT64_C(0x50333200)&&address<UINT64_C(0x50333270)) {n=0;base=UINT64_C(0x50333200);}
 else if(address>=UINT64_C(0x50333280)&&address<UINT64_C(0x503332f0)) {n=1;base=UINT64_C(0x50333280);}
 else return false;
 O62MHashWorkHostV7 *h=&m->host[n];unsigned depth=n?(cq&31):((cq>>5)&31);
 if(!depth||h->cq_words>depth||h->csq_words>15)return false;
 unsigned offset=(unsigned)(address-base);uint32_t *config=NULL;
 if(offset==0) {
  unsigned expected=o62m_hash_frame_words_v7(h,(uint32_t)*value);
  if(!write||n!=1||h->cq_words||h->csq_words||!expected||depth<expected||
     (h->control&UINT32_C(0xc1))!=UINT32_C(0xc1))return false;
  h->cq[0]=(uint32_t)*value;h->cq_words=1;return true;
 }
 if(offset==4) {
  unsigned expected=o62m_hash_frame_words_v7(h,h->cq[0]);
  if(!write||n!=1||!expected||h->cq_words<1||h->cq_words>=expected)return false;
  h->cq[h->cq_words++]=(uint32_t)*value;return true;
 }

 if(offset==12)config=&h->control;
 else if(offset>=64&&offset<=72)config=&h->mask[(offset-64)/4];
 else if(offset==108)config=&h->suspend;
 if(config) {if(write) {if(h->cq_words)return false;*config=(uint32_t)*value;}else *value=*config;return true;}
 if(offset==16) {
  if(write)return false;
  *value=((depth-h->cq_words)<<11)|(h->csq_words<<7)|(h->cq_words?2u:((h->control&128)?1u:0u));return true;
 }
 if(offset==20||offset==24||offset==28) {
  unsigned index=(offset-20)/4;
  if(write) {h->pending[index]&=~((uint32_t)*value&~(index?0u:1u));}
  else {*value=h->pending[index];}
  return true;
 }
 if(offset==8) {
  if(write||!h->csq_words)return false;
  uint32_t result=h->csq[0];
  memmove(h->csq,h->csq+1,(h->csq_words-1)*sizeof h->csq[0]);
  h->csq[--h->csq_words]=0;*value=result;return true;
 }
 return false;
}
/* Only caller that has completed the actual private INIT work may publish.
 * No time/readcount or command acceptance path calls this automatically. */
static inline bool o62m_hash_work_complete_v7(O62MHashWorkQueueV7 *m,uint32_t expected_header,unsigned code)
{
 if(!m||!m->initialized)return false;
 O62MHashWorkHostV7 *h=&m->host[1];
 unsigned words=o62m_hash_frame_words_v7(h,expected_header);
 if(!words||h->cq_words!=words||h->cq[0]!=expected_header||h->csq_words>=15||
    code!=((expected_header>>24)==0x80?1u:(expected_header==UINT32_C(0x40000019)||expected_header==UINT32_C(0x40000003)||expected_header==UINT32_C(0x40000039))?2u:expected_header==UINT32_C(0x2000003f)?3u:7u))return false;
 if(code==1)h->finish_words=(expected_header&16)?7:3;else if(code==7)h->finish_words=0;
 h->csq[h->csq_words++]=code<<5; /* actual command code,slot0,status0 */
 h->pending[1]|=1;memset(h->cq,0,sizeof h->cq);h->cq_words=0;return true;
}
static inline unsigned o62m_hash_work_irq_aggregate_v7(const O62MHashWorkQueueV7 *m)
{
 unsigned result=0;if(!m||!m->initialized)return 0;
 for(unsigned n=0;n<2;n++) {
  const O62MHashWorkHostV7 *h=&m->host[n];
  if((h->pending[0]&~h->mask[0])||(h->pending[1]&~h->mask[1])||(h->pending[2]&~h->mask[2]))
   result|=n?1u:2u;
 }
 return result;
}
#endif
